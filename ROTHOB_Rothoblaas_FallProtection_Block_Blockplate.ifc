Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 2742baa6-e8fd-44e0-af98-1048cf8ba4ee, NumberOfSaves: 36], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_FallProtection_Block_Blockplate.ifc
Time: 2025-07-18T11:28:11
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcBuildingElementProxy: Attrezzature speciali : ROTHOB_Rothoblaas_FallProtection_BLOCK : BLOCK+BLOCKPLATE_1891x1669x210mm
In: 0_Rothoblaas
Type - ElementType: FALL_ARRESTER_DEVICES; PredefinedType: USERDEFINED; Material: <Unnamed>, ROTHOB_Rothoblaas_StainlessSteelAISI304, Concrete, Precast
Type - Visibilità - BLOCKMAT: no; BLOCKPLATE: yes; N°Ballast=24: no
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_BLOCK; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fall-protection-system/anchor-lines/components/block; Revision: 001; UniClass2015Code: Pr_40_70_75_75; UniClass2015Title: Safety access anchor devices; UniClass2015Version: Products v1.38; Version: 001
Type - Vincoli - Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteelAISI304
Type - Quote - H_BLOCKMAT: 0 mm; Height_H: 165.5 mm; Lenght_L: 1891.24 mm; Width_B: 1668.53 mm
Type - Dati identità - Descrizione: Support with ballast for fall protection systems for non-drillable green roofs and flat roofs (slope up to 5°); Nome del tipo: BLOCK+BLOCKPLATE_1891x1669x210mm; Numero OmniClass: 23.27.71.21; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Attrezzature speciali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_75_75 - Safety access anchor devices; CodePerformance: CE - Safety system; Color: Grey; Constituents: n/a; DurationUnit: Years; ExpectedLife: n/a; Features: Horizontal lifeline and anchor points; Finish: Stainless steel; Grade: n/a; GTIN: BLOCK: 8052877750641 / BLOCKPLATE: 8054045435831; Material: AISI 304 stainless steel grade 1.4301; MinWeight: BLOCK 19.3 kg / BLOCK with 18 ballasts 400 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website // BLOCKMAT, BLOCKPLATE and Ballasts are not included with the purchase of BLOCK; ModelNumber: BLOCK; ModelReference: n/a; Name: Support for fall protection systems; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_BLOCK; NominalHeight: 165.5 mm; NominalLength: 1891.24 mm; NominalWidth: 1668.53 mm; ReferenceStandard: with PATROL: EN 795:2012 C | CEN/TS 16415:2013 | UNI 11578:2015 C // with AOS01: EN 795:2012 E; ReplacementCost: n/a; Shape: Three-dimensional; Size: 1891x1669x210 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Support for fall protection systems; Category: Pr_40_70_75_75 - Safety access anchor devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: BLOCK+BLOCKPLATE_1891x1669x210mm; sets with these values: 2
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 8.7213 m2; Volume: 0.250395 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_BLOCK; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_BLOCK: BLOCK+BLOCKPLATE_1891x1669x210mm; ID tipo: 441594; Tipo: BLOCK+BLOCKPLATE_1891x1669x210mm
